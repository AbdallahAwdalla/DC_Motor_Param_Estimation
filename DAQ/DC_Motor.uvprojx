# Keil uVision project DC_Motor.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DC_Motor
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: mian.c common.h Timer.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.5.0
